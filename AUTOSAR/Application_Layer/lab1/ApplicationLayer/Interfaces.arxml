<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 file:///C:/Users/ayman/Documents/autosar/lab1/AUTOSAR_ARXML_Schema/AUTOSAR_00049.xsd">
	<AR-PACKAGES>
		<AR-PACKAGE>
			<SHORT-NAME>INTERFACES</SHORT-NAME>
			<AR-PACKAGES>
				<AR-PACKAGE>
					<SHORT-NAME>INTERFACES1</SHORT-NAME>
				</AR-PACKAGE>
				<AR-PACKAGE>
					<SHORT-NAME>INTERFACES2</SHORT-NAME>
				</AR-PACKAGE>
			</AR-PACKAGES>
		</AR-PACKAGE>
	</AR-PACKAGES>
</AUTOSAR>